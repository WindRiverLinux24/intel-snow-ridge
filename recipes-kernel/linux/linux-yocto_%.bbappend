require linux-yocto-intel-snow-ridge.inc
